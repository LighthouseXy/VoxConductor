# Repository LighthouseXy/VoxConductor

File README.md:

# VoxConductor｜棱镜显示桌面语音助手

[简体中文](README.md) · [English](README.en.md) · [中文副本](README.zh-CN.md)

VoxConductor 是一台基于 ESP32-S3 的桌面语音助手，整合定制 PCB、屏幕与分光棱镜、麦克风、扬声器、按键和姿态交互。设备负责界面、音频、工具执行与本地记录；ASR、模型问答和 TTS 使用云端服务，无需电脑常驻运行服务端。

棱镜呈现的是二维画面的悬浮观感。固件界面目前仅有中文，英文 README 不代表设备支持英文界面。

更新：2026-11-03。开发源码与宿主测试已同步；照片和视频保留原拍摄版本。[最新进度](docs/PROGRESS.md) · [验证记录](docs/SYNC_VALIDATION.md) · [开发与维护记录](DEVELOPMENT_HISTORY.md)。

## 硬件

52 × 50 mm 四层 PCB，ESP32-S3-WROOM-1，240 × 240 ST7789 系列显示屏，INMP441 麦克风、MAX98357A I2S 功放及 MPU 姿态传感器。使用实体按键和倾斜操作，不依赖触摸屏；固件基于 ESP-IDF / FreeRTOS 与 LVGL 9。

[硬件工程](hardware/README.md) 包含 KiCad、制造和 V3-SLA 结构资料；[板级 BOM](hardware/BOM.md) 覆盖 61 个器件位置，不是整机采购清单。实物 J2 返修尚未写回设计，V3-SLA 仍待打印试装；再次制板前须修订并复核。

## 软件功能

| 方向 | 当前代码能力 |
| --- | --- |
| 桌面与天气 | 时钟、壁纸、亮度与方向设置；当前天气、未来 12 小时预报、UV、US AQI / PM2.5、风与湿度 |
| 语音与工具 | 本地“小冰小冰”唤醒、按键说话、连续接话与取消；时间/天气查询、音量/主页设置及受限工具调用 |
| 日常与媒体 | 闹钟、提醒、待办、备忘录、倒计时、番茄钟；SD 音乐/环境音/壁纸与同网网页管理 |
| 记录与恢复 | 有界近期上下文、带来源和有效期的记忆、历史检索与删除；SD 文字记录和双槽校验快照 |

天气来自网络服务，不是板载环境检测；照片中的数值只代表拍摄时刻。上述是代码功能范围，设备可靠性仍按下述验证层级区分。

## 语音流程

1. 按键或 WakeNet 触发采集，16 kHz 实时 ASR 返回转写。
2. 本地精确命令直接处理；其他问题进入有限模型工具循环。示例配置使用 Qwen ASR/TTS 与 DeepSeek，需网络和自有服务凭据。
3. 设备校验参数与确认条件，执行后将真实结果交回模型；设备动作结果未知时不自动重放。
4. 释放模型连接后建立 24 kHz TTS 会话，通过 I2S 播放；成功轮次结束后提交上下文，并在连续对话窗口等待下一句。

模型提出的提醒和备忘录先形成候选，须下一轮精确“确认执行”。“查看任务保存状态”读取磁盘快照；“重试任务保存”先对账，已有 ID 同步运行态且不重写，未保存事项重新等待确认。“取消执行”清除待确认与重试授权；取消或进程重载不会自动恢复授权。

## 当前进度与待优化项

| 状态 | 依据与范围 |
| --- | --- |
| 已有演示 | 下方视频记录基础查询与音量控制；不代表最新源码的全部行为 |
| 已做离线验证 | 2026-11-03 Agent 五组宿主测试、任务快照对账/重载及三项源码契约检查通过；包含模拟输入、虚拟时钟与故障注入 |
| 构建记录 | 2026-10-25 本地 ESP32-S3 构建通过；11 月 3 日同步分支未重新构建或刷机 |
| 待实机验收 | 唤醒词打断、播报连续性、网页上传/保存与语音争用、SD 断电恢复、内存峰值和端到端延迟 |
| 计划 | 多设备行动预览、能力注册、跨天任务续办与可控主动提醒 |

语音仍需按距离、发音和噪声环境验证，不作为稳定全双工能力；180 秒软件预算也不是 SD 或驱动清理的硬实时保证。云服务的可用性、费用和数据条款需自行确认。

## 演示视频

| 唤醒、时间与天气查询 · 约 26 秒 | 语音调节音量 · 约 29 秒 |
| --- | --- |
|  |  |

提问阶段音轨已变调，画面顺序与时长保留，详见[视频说明](docs/videos/2026-10-10/README.md)。单次演示不能证明识别率、延迟或长期稳定性；更多照片见[展示图集](docs/SHOWCASE.md)。

## 文档与复现

目标为 ESP32-S3 / ESP-IDF 6.0.2，组件版本记录于 `firmware/dependencies.lock`。按[配置说明](docs/DEVICE_CLOUD_VOICE.md)从 [Wi-Fi 示例](firmware/main/wifi_credentials.example.h)等模板创建本地配置，并自行提供有使用权的 24 kHz、16-bit little-endian 单声道 `firmware/main/reminder.pcm`，再在 `firmware` 目录运行 `idf.py build`。提醒音和真实凭据未入库，干净克隆不能跳过这些前提；Flash/PSRAM 配置须匹配实物。SD 对话是明文，不应上传私人记录。

| 入口 | 内容 |
| --- | --- |
| [文档导航](docs/README.md) | 完整资料入口 |
| [硬件设计与装配](docs/HARDWARE_DESIGN.md) / [接线](docs/HARDWARE_V1.md) | PCB、部件、GPIO 与结构边界 |
| [技术架构](docs/TECHNICAL_ARCHITECTURE.md) / [语音与记忆](docs/VOICE_DIALOGUE_AND_MEMORY_PLAN.md) | 链路、资源、执行和持久化 |
| [功能与页面](docs/FEATURES.md) / [桌面交互](docs/DESKTOP_TOOLS_AND_GAMES.md) | 页面和操作说明 |
| [网页管理](docs/WEB_MANAGEMENT_DESIGN.md) | 接口与验收方法 |
| [后续计划](docs/ROADMAP.md) / [发布清单](docs/GITHUB_PUBLICATION_CHECKLIST.md) | 优先级与公开范围 |
| [V1 历史架构](docs/ARCHITECTURE.md) / [旧验证记录](docs/DEMO_AND_VERIFICATION.md) | 早期 FastAPI 阶段，非当前生产必经服务 |

## 许可与归属

仅[许可范围](LICENSE_SCOPE.md)及其清单列明的项目原创软件与原创技术文档采用 [MIT License](LICENSE)，允许按许可商业使用、修改和再分发，须保留版权及许可声明。`hardware/**`（含机械脚本）、依赖、字体、图片、影音和数据不纳入项目 MIT 授权，保留各自权利；见[第三方说明](THIRD_PARTY_NOTICES.md)。

天气与空气质量来自 Open-Meteo，空气质量来源包含 CAMS，见[数据服务说明](https://open-meteo.com/en/docs/air-quality-api)。ESP-IDF、LVGL、ESP-SR、云服务及第三方媒体适用各自条款；音乐归属随媒体包保留。

## KiCad design hardware/VoxConductor.kicad_pcb

File hardware/README.md:

# VoxConductor 硬件设计

更新：2026-10-11。这里统一保存当前 KiCad 工程、制造文件与 V3-SLA 结构，旧方案和临时文件不放进活动目录。

## 文件入口

| 资料 | 入口 | 用途 |
| --- | --- | --- |
| KiCad 工程 | [VoxConductor.kicad_pro](VoxConductor.kicad_pro) | 用 KiCad 10 打开；原理图、PCB、项目库均在本目录 |
| 原理图 | [可浏览 PDF](exports/VoxConductor-schematic.pdf)、[源文件](VoxConductor.kicad_sch) | 完整单页主原理图 |
| PCB | [源文件](VoxConductor.kicad_pcb)、[顶层图](exports/pcb-top.svg) | 52 × 50 mm、四层板 |
| 板载物料 | [电子 BOM 说明](BOM.md)、[分组 CSV](exports/board-bom.csv)、[逐位号 CSV](exports/board-bom-detailed.csv) | 61 个位置，与原理图网表核对；含 2 个 DNP，采购规格另行确认 |
| 制板资料 | [2026-09-16 制造文件](fabrication/2026-09-16/README.md) | 已制板源版本的 Gerber、钻孔与坐标表 |
| 3D 外壳 | [V3-SLA 装配与打印说明](mechanical/V3-SLA/README.md) | STEP、STL、FreeCAD、PPT、预览和重建脚本 |
| 板级接线 | [硬件与 GPIO](../docs/HARDWARE_V1.md) | 固件接口与通电检查 |
| 供应商依据 | [显示屏](docs/display/README.md)、[扬声器](docs/audio/README.md) | 原始尺寸资料及接口限制 |
| 本轮校验 | [checks/README.md](checks/README.md)、[文件哈希](manifest.json) | 设计静态检查与交付完整性 |

## 版本与装配边界

KiCad 三个主文件与 2026-09-16 最终制板记录逐字节相同。本次整理未修改网络、铜线或器件位置，也没有生成新的投板修订。

实物屏幕接口J2曾旋转180°返修，待同步至KiCad和生产图。FH12立式插座要求排线金属接触面背向棕色锁扣，针序需与原理图一起核对。再次上电或制板前须完成接口修正与审图。

V3-SLA修复外壳USB左右镜像和PCB装入时的螺丝柱干涉，需成套替换主壳、底盖及扬声器托架。CAD检查已通过；树脂试装、线束弯折和螺纹强度待实测。先打印入口框和底盖，单件打印使用相应STL，装配STEP用于结构核对。

`lib/` 保留主工程使用的三个项目封装及符号库；标准库与标准3D模型由KiCad 10提供。J2等自定义器件的完整厂家模型待补齐，现有结构校验使用PCB平面数据和保守高度包络。

GitHub 保存展开文件，不同时保存 ZIP 副本。生产方需要 ZIP 时，仅压缩制造目录的生产文件；结构打印包可用 `mechanical/V3-SLA/source/package.py --output <工程目录外的路径>` 生成。

Parts:
C1, C6, C11, C12, C14, C17, C18, C19, C21: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C5, C10, C20, C22: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C3: 22uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C4: 6.8pF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C7: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C8, C9: DNP; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder; not fitted
C13: 10nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C15: 2.2nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C23: 100nF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
J1: USB_C_Receptacle_USB2.0_16P; USB_C_Receptacle_HRO_TYPE-C-31-M-12
J2: FH12-12S-0.5SVA(54); Hirose_FH12-12S-0.5SVA_Vertical
J3: 53261-0271; Molex_PicoBlade_53261-0271_1x02-1MP_P1.25mm_Horizontal
J4: Micro_SD_Card_Det2; microSD_HC_Molex_104031-0811
J7: S2B-PH-K-S(LF)(SN); JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
L1: 2.2uH; L_Bourns-SRN4018
Q1: SS8050; SOT-23
R1, R8, R13, R14, R15, R17, R18, R23: 10K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2: 453k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 100k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R4, R5: 5.1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6, R7, R16: 22R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9, R10: 4.7K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R11: 100K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R12: 2.2K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R20: 0R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R21: 10R; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R22: 1K; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R24: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R25: 1k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1, SW2: TS-1088-AR02016; SW_SPST_TS-1088-xR020
U1: ESP32-S3-WROOM-1; ESP32-S3-WROOM-1_Thermal_0p3
U2: TLV62569DBV; SOT-23-5
U3: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm
U4: USBLC6-2SC6; SOT-23-6
U5: INMP441ACEZ-R7
U6: MAX98357AETE+T; TQFN-16-1EP_3x3mm_P0.5mm_EP1.23x1.23mm

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C12.1, C13.1, C17.1, C18.1, C21.1, C22.1, J2.3, J2.4, J4.4 (VDD), L1.2, R1.1, R2.1, R8.1, R9.1, R10.1, R12.1, R13.1, R14.1, R15.2, R17.2, R18.2, R24.1, U1.2 (3V3), U3.8 (VLOGIC), U3.13 (VDD), U5.7 (VDD), U5.8 (CHIPEN)
+5V: C5.1, C6.1, C10.1, C11.1, C19.1, C20.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U2.1 (EN), U2.4 (VIN), U4.5 (VBUS), U6.7 (VDD), U6.8 (VDD)
/CHIP_PU: C7.1, R1.2, SW2.2, U1.3 (EN)
/GPIO0: R8.2, SW1.2, U1.27 (IO0)
/J_SPK.1: J3.1, U6.9 (OUTP)
/J_SPK.2: J3.2, U6.10 (OUTN)
/LED_K: J2.2, R21.1
/MPU_INT: U1.34 (IO41), U3.12 (INT)
/MPU_SCL: R10.2, U1.33 (IO40), U3.23 (SCL)
/MPU_SDA: R9.2, U1.32 (IO39), U3.24 (SDA)
/USB_CONN_N: J1.A7 (D-), J1.B7 (D-), U4.1 (I/O1)
/USB_CONN_P: J1.A6 (D+), J1.B6 (D+), U4.3 (I/O2)
/USB_D+: C8.1, R6.2, U1.14 (USB_D+)
/USB_D-: C9.1, R7.2, U1.13 (USB_D-)
/USB_PROTECTED_N: R7.1, U4.6 (I/O1)
/USB_PROTECTED_P: R6.1, U4.4 (I/O2)
AMP_BCLK: U1.5 (IO5), U6.16 (BCLK)
AMP_DIN: U1.4 (IO4), U6.1 (DIN)
AMP_LRC: U1.6 (IO6), U6.14 (LRCLK)
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.SH (SHIELD), J2.1, J2.5, J2.6, J2.12, J4.6 (VSS), J4.SH (SHIELD), J7.2, Q1.2 (E), R3.2, R4.1, R5.2, R11.2, R20.1, R23.2, SW1.1, SW2.1, U1.1 (GND), U1.40 (GND), U1.41 (GND), U2.2 (GND), U3.1 (CLKIN), U3.9 (AD0), U3.11 (FSYNC), U3.18 (GND), U4.2 (GND), U5.4 (L/R), U5.5 (GND), U5.6 (GND), U5.9 (GND), U6.3 (GND), U6.11 (GND), U6.15 (GND), U6.17 (PAD)
KEY_USER1: C23.1, R24.2, R25.2, U1.9 (IO16)
LCD_BL: R22.1, U1.17 (IO9)
LCD_DC: J2.7, U1.19 (IO11)
LCD_MOSI: J2.10, U1.18 (IO10)
LCD_RST: J2.11, U1.20 (IO12)
LCD_SCLK: J2.9, U1.21 (IO13)
MIC_SCK: U1.38 (IO2), U5.1 (SCK)
MIC_SD: R11.1, U1.35 (IO42), U5.2 (SD)
MIC_WS: U1.39 (IO1), U5.3 (WS)
unnamed: J1.A5 (CC1), R4.2
unnamed: J1.B5 (CC2), R5.1
unnamed: J2.8, R20.2
unnamed: J4.5 (CLK), R16.1
unnamed: J4.8 (DAT1), R18.1
unnamed: J4.1 (DAT2), R13.2
unnamed: J7.1, R25.1
unnamed: Q1.1 (B), R22.2, R23.1
unnamed: Q1.3 (C), R21.2
unnamed: C4.2, R2.2, R3.1, U2.5 (FB)
unnamed: L1.1, U2.3 (SW)
unnamed: C15.1, U3.20 (CPOUT)
unnamed: C14.1, U3.10 (REGOUT)
unnamed: R12.2, U6.4 (~SD_MODE)
SD_CS: J4.2 (DAT3/CD), R14.2, U1.25 (IO48)
SD_MISO: J4.7 (DAT0), R17.1, U1.22 (IO14)
SD_MOSI: J4.3 (CMD), R15.1, U1.24 (IO47)
SD_SCK: R16.2, U1.23 (IO21)

Notes on the sheet:
按键与启动控制
显示屏接口
3.3V降压电源
J7：R13-507，双线直焊
ESP32主控
姿态传感器
USB接口与静电保护
音频功放与扬声器
数字麦克风
MicroSD存储

Board: 4 copper layers, 52.0 x 50.0 mm, 64 parts (0 on the bottom side), 47 nets.

Other parts of the board:
H1, H2, H3: MountingHole_2.2mm_M2

File hardware/BOM.md:

# 定制 PCB 物料清单

更新：2026-10-11。此表对应仓库中的 KiCad 原理图，不是早期模块原型清单，也不是已完成采购审核的替代件清单。

我将原始分组 BOM 展开为逐位号明细，并与本次重新导出的 KiCad 网表核对：**61 个器件位置，59 个拟装配位置，C8、C9 两个 DNP 位置**。器件值与封装逐项一致；位号并不连续，不能按最大编号计算数量。

| 文件 | 用途 |
| --- | --- |
| [分组 BOM](exports/board-bom.csv) | 保留原理图的原始名称、分组、封装和 DNP 标记 |
| [逐位号 BOM](exports/board-bom-detailed.csv) | 每行一个位号，便于核对焊接、贴装和采购数量 |
| [原理图 PDF](exports/VoxConductor-schematic.pdf) | 核对网络连接和器件所在电路 |
| [制板坐标表](fabrication/2026-09-16/README.md) | 制造资料的入口；下单前重新核对修订版本 |

## 1. 数量汇总

| 类别 | 位置数 | 拟装配数 |
| --- | ---: | ---: |
| 电阻 R | 24 | 24 |
| 电容 C | 22 | 20 |
| IC / 主控模组 U | 6 | 6 |
| 连接器 J | 5 | 5 |
| 开关 SW | 2 | 2 |
| 电感 L | 1 | 1 |
| 三极管 Q | 1 | 1 |
| 合计 | 61 | 59 |

“拟装配”依据原理图 DNP 标记，不是对照片中每个焊点的验收结论。原理图内 R19、C16、J5、J6 等编号未出现，不自行补入物料。

## 2. 电阻

全部采用原理图指定的 0805 封装。此处仅统一大小写与单位；完整封装名见 CSV。

| 阻值 | 位号 | 数量 |
| --- | --- | ---: |
| 0 Ω | R20 | 1 |
| 10 Ω | R21 | 1 |
| 22 Ω | R6、R7、R16 | 3 |
| 1 kΩ | R22、R25 | 2 |
| 2.2 kΩ | R12 | 1 |
| 4.7 kΩ | R9、R10 | 2 |
| 5.1 kΩ | R4、R5 | 2 |
| 10 kΩ | R1、R8、R13–R15、R17、R18、R23、R24 | 9 |
| 100 kΩ | R3、R11 | 2 |
| 453 kΩ | R2 | 1 |

## 3. 电容

| 容值 | 位号 | 封装 | 数量 | 装配 |
| --- | --- | --- | ---: | --- |
| 6.8 pF | C4 | 0805 | 1 | 装配 |
| 2.2 nF | C15 | 0805 | 1 | 装配 |
| 10 nF | C13 | 0805 | 1 | 装配 |
| 100 nF / 0.1 µF | C1、C6、C11、C12、C14、C17–C19、C21、C23 | 0805 | 10 | 装配 |
| 1 µF | C7 | 0805 | 1 | 装配 |
| 10 µF | C2、C5、C10、C20、C22 | 1206 | 5 | 装配 |
| 22 µF | C3 | 1206 | 1 | 装配 |
| 未指定容值 | C8、C9 | 0805 | 2 | DNP，不装配 |

## 4. 主控、IC 与其他板载元件

| 位号 | 原理图型号 / 值 | 职责或封装依据 |
| --- | --- | --- |
| U1 | ESP32-S3-WROOM-1 | 主控、Wi-Fi；项目定制焊盘。完整模组后缀待补，不由名称推断 Flash/PSRAM 容量 |
| U2 | TLV62569DBV | 降压电源，SOT-23-5 |
| U3 | MPU-6050 | 姿态传感器，QFN-24，4 × 4 mm |
| U4 | USBLC6-2SC6 | USB 接口静电保护，SOT-23-6 |
| U5 | INMP441ACEZ-R7 | 数字 MEMS 麦克风，项目封装 |
| U6 | MAX98357AETE+T | I2S 输入功放，TQFN-16，3 × 3 mm |
| L1 | 2.2 µH | 采用 Bourns SRN4018 封装；不是完整电感采购型号 |
| Q1 | SS8050 | 三极管，SOT-23；替换时必须核对引脚定义 |
| SW1、SW2 | TS-1088-AR02016 | 板载按键开关，共 2 个 |

## 5. 连接器

| 位号 | 原理图值 / 封装依据 | 数量 |
| --- | --- | ---: |
| J1 | USB-C USB2.0 16P；HRO TYPE-C-31-M-12 封装 | 1 |
| J2 | Hirose FH12-12S-0.5SVA(54)，12P、0.5 mm、立式 | 1 |
| J3 | Molex PicoBlade 53261-0271，2P、1.25 mm | 1 |
| J4 | microSD 卡座，Molex 104031-0811 封装 | 1 |
| J7 | JST S2B-PH-K-S(LF)(SN)，2P、2.0 mm | 1 |

J2 实物曾旋转 180° 返修，尚未写回当前 KiCad 文件。下一次制板前必须修订并重新核对 FPC 针序、接触面及插座方向，不能直接复用现有制造包。

## 6. 整机材料与采购前检查

PCB BOM 不包含屏幕、分光棱镜、扬声器、外接操作按键、外壳、透明支架、线束、螺钉与 SD 卡。这些按整机材料记录在 [硬件设计与装配](../docs/HARDWARE_DESIGN.md#4-装配部件每一部分负责什么)，不与板载电子元器件混计。

目前仍需补齐：无源元件的额定电压、容差、介质及功率；电感的完整料号、额定/饱和电流；模组完整后缀；连接器的实际采购型号和供应商。不能仅凭“0805、10 kΩ”就确认替代件。采购前按电路电压、电源负载、封装焊盘和数据手册逐项核对，再将确认过的料号写入新的采购版本。

[硬件工程](README.md) · [电气与 GPIO](../docs/HARDWARE_V1.md)

## Code that names these connections

File tests/test_board_pins.py:

"""Board pin and calibration source guards. Native driver and electrical acceptance run separately."""
from pathlib import Path
import re
import sys
import xml.etree.ElementTree as ET

ROOT = Path(__file__).resolve().parents[1]
# Frozen from the user-confirmed VoxConductor schematic on 2026-09-25.
PINS = {
    "app_display.c": {
        "LCD_PIN_DC": ("LCD_DC", 11), "LCD_PIN_RST": ("LCD_RST", 12),
        "LCD_PIN_MOSI": ("LCD_MOSI", 10), "LCD_PIN_SCLK": ("LCD_SCLK", 13),
        "LCD_PIN_BL": ("LCD_BL", 9),
    },
    "app_audio.c": {
        "MIC_PIN_SCK": ("MIC_SCK", 2), "MIC_PIN_WS": ("MIC_WS", 1),
        "MIC_PIN_SD": ("MIC_SD", 42), "SPEAKER_PIN_BCLK": ("AMP_BCLK", 5),
        "SPEAKER_PIN_LRC": ("AMP_LRC", 6), "SPEAKER_PIN_DIN": ("AMP_DIN", 4),
    },
    "app_storage.c": {
        "SD_PIN_CS": ("SD_CS", 48), "SD_PIN_SCK": ("SD_SCK", 21),
        "SD_PIN_MOSI": ("SD_MOSI", 47), "SD_PIN_MISO": ("SD_MISO", 14),
    },
    "app_button.c": {"APP_BUTTON_PIN": ("KEY_USER1", 16)},
    "app_motion.h": {
        "APP_MOTION_SDA_GPIO": ("/MPU_SDA", 39),
        "APP_MOTION_SCL_GPIO": ("/MPU_SCL", 40),
    },
}

netlist = ET.parse(sys.argv[1]).getroot() if len(sys.argv) > 1 else None
used = {}
for filename, pins in PINS.items():
    source = (ROOT / "firmware/main" / filename).read_text()
    for macro, (net, expected) in pins.items():
        match = re.search(r"^#define\s+" + macro + r"\s+(?:GPIO_NUM_)?(\d+)\s*$", source, re.M)
        assert match, f"Missing GPIO definition: {macro}"
        actual = int(match[1])
        assert actual == expected, f"{macro}: expected {expected}, got {actual}"
        assert actual not in used, f"GPIO{actual} conflict: {macro} / {used.get(actual)}"
        assert actual not in (0, 19, 20, 35, 36, 37, 41), f"Reserved GPIO: {macro}"
        used[actual] = macro
        if netlist is not None:
            nodes = [p for n in netlist.findall("./nets/net") if n.get("name") == net
                     for p in n.findall("node") if p.get("ref") == "U1"]
            assert len(nodes) == 1, f"Missing/ambiguous MCU node: {net}"
            assert re.fullmatch(rf"IO{actual}_\d+", nodes[0].get("pinfunction", "")), net
print(f"PASS: {len(used)} PCB GPIOs match; no conflicts;" +
      (" KiCad netlist verified" if netlist is not None else " frozen mapping verified"))

# Backlight controls preserve pins, optical compensation and buffers.
display = (ROOT / "firmware/main/app_display.c").read_text()
assert '#include "driver/ledc.h"' in display
assert re.search(r"LCD_BL_PWM_HZ\s+5000\b", display)
assert "LEDC_TIMER_10_BIT" in display
for config in (".mirror_x = true", ".mirror_y = false", ".swap_xy = false",
               ".double_buffer = false", ".buff_dma = true"):
    assert config in display, f"Display contract changed: {config}"
assert "esp_lcd_panel_set_gap(panel_handle, 0, 0)" in display
assert "percent > 100" in display and "ESP_ERR_INVALID_ARG" in display
assert "atomic_load(&s_ready)" in display and "ESP_ERR_INVALID_STATE" in display
assert ".duty = 0" in display and "gpio_set_level(LCD_PIN_BL, 1)" not in display
assert display.index("lv_display_set_default(display)") < display.index(
    "result = app_display_set_brightness(100)")
assert "xSemaphoreCreateMutexStatic" in display
assert "ledc_set_duty(" in display and "ledc_update_duty(" in display
assert "ledc_fade_func_install" not in display
assert "esp_driver_ledc" in (ROOT / "firmware/main/CMakeLists.txt").read_text()
for source in (ROOT / "firmware/main").glob("*.c"):
    if source.name != "app_display.c":
        assert not re.search(r"\bledc_(?:timer_config|channel_config)\s*\(",
                             source.read_text()), f"LEDC resource collision: {source}"
duties = [((1 << 10) * percent + 50) // 100 for percent in range(101)]
assert duties[0] == 0 and duties[-1] == 1024
assert all(a <= b for a, b in zip(duties, duties[1:]))

motion = (ROOT / "firmware/main/app_motion.c").read_text()
header = (ROOT / "firmware/main/app_motion.h").read_text()
for api in ("app_motion_available", "app_motion_request_calibration",
            "app_motion_calibrating"):
    assert f"bool {api}(void)" in motion and f"bool {api}(void)" in header
assert re.search(r"age\s*<=\s*200000", motion)
assert re.search(r"if\s*\(!app_motion_available\(\)\)\s*return false;", motion)
assert "atomic_exchange(&s_calibration_requested, false)" in motion
assert "motion_input_reset_calibration(&input)" in motion
assert "vertical_calibration = (motion_recenter_t){0}" in motion
assert "input.calibrated && vertical_calibrated" in motion
assert "bool recovering = valid && !app_motion_available()" in motion
assert re.search(r"if\s*\(!valid\)\s*invalidate_sample\(\)", motion)
read_failure = motion[motion.index("if (result != ESP_OK)",
                                   motion.index("while (true)")):]
assert read_failure.index("invalidate_sample()") < read_failure.index("vTaskDelay(")
assert "direction && !calibrating && !atomic_load(&s_calibrating)" in motion
gesture = (ROOT / "firmware/main/app_motion_gesture.h").read_text()
reset = gesture[gesture.index("static inline void motion_input_reset_calibration"):]
reset = reset[:reset.index("static inline int motion_input_step")]
assert "require_stable_center = true" in reset and "s->neutral =" not in reset
assert "MOTION_RECENTER_MS 1000" in gesture
print('PASS: PWM range/startup/driver resources and fresh motion/manual stable calibration source guards; scope=offline checks; pending=hardware/C validation')
